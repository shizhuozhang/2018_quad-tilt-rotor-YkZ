# Keil uVision project Tiltor-FreeRTOS.uvprojx, settings and files
target Tiltor-FreeRTOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\config;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\usart;..\HARDWARE\IO;..\HARDWARE\ADC;..\HARDWARE\PWMOUT;..\HARDWARE\TIMER;..\HARDWARE\PID_CONTROL;..\HARDWARE\SBUS_DATA;..\HARDWARE\AHRS;..\HARDWARE\SPI;..\HARDWARE\DMA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c Tsk_manage.c
  group HARDWARE
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IO/: IO.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWMOUT/: pwm.c
    ../HARDWARE/SBUS_DATA/: SBUS.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/DMA/: DMA.c
    ../HARDWARE/AHRS/: AHRS.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/config/: stm32f4xx_conf.c
  group STM32CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
