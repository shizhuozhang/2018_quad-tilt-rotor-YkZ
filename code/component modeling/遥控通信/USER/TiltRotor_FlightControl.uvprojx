# Keil uVision project TiltRotor_FlightControl.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\SYS;..\APPLICATION\delay;..\APPLICATION\usart;..\APPLICATION;..\APPLICATION\ADC;..\APPLICATION\IO;..\APPLICATION\PWMOUT;..\APPLICATION\SBUS_DATA;..\APPLICATION\TIMER;..\APPLICATION\DMA;..\APPLICATION\AHRS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SOURCE
    ./: startup_stm32f40_41xxx.s
  group USER
    ./: main.c
  group SYS
    ../SYS/: sys.c
  group APPLICATION
    ../APPLICATION/delay/: delay.c
    ../APPLICATION/usart/: usart.c
    ../APPLICATION/: H_define.c
    ../APPLICATION/IO/: IO.c
    ../APPLICATION/SBUS_DATA/: SBUS.c
    ../APPLICATION/TIMER/: timer.c
    ../APPLICATION/DMA/: DMA.c
    ../APPLICATION/AHRS/: AHRS.c
    ../APPLICATION/PWMOUT/: pwm.c
    ../APPLICATION/ADC/: adc.c
