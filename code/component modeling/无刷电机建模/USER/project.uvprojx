# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\USART;..\HARDWARE;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\HARDWARE\IO;..\HARDWARE\PWMOUT;..\HARDWARE\ENCODER;..\HARDWARE\PWMIN;..\HARDWARE\ADC;..\HARDWARE\MPU9250;..\HARDWARE\DMA_USART;..\HARDWARE\FLASH;..\HARDWARE\CAP;..\HARDWARE\PID_CONTROL;..\HARDWARE\SBUS_DATA
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: startup_stm32f10x_hd.s main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/: H_define.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/IO/: IO.c
    ../HARDWARE/PWMOUT/: pwm.c
    ../HARDWARE/PWMIN/: pwmin.c
    ../HARDWARE/CAP/: cap.c
software components: CMSIS:CORE 4.3.0
